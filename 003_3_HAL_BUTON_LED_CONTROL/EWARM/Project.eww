<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\003_HAL_BUTON_LED_CONTROL.ewp</path>
  </project>
  <batchBuild />
</workspace>
