<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\006_5_HAL_REAL_ADC_VOLTAGE_AND_MULTI_ADC.ewp</path>
  </project>
  <batchBuild />
</workspace>
